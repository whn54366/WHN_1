## boards/shields/whn1/Kconfig.defconfig
```kconfig
if SHIELD_WHN1

config ZMK_KEYBOARD_NAME
    default "whn1"

endif # SHIELD_WHN1
```
